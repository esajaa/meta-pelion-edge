RDEPENDS_${PN}-npm = "bash python3 python3-shell python3-core python3-datetime python3-multiprocessing python3-crypt python3-netclient python3-misc"

INSANE_SKIP_${PN}-npm += "file-rdeps"
